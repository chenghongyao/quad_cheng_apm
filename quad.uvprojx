# Keil uVision project quad.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: quad
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\user\include;.\lib\include;.\software\include;.\driver\table;.\driver\esp8266;.\driver\hmc5883;.\driver\led;.\driver\motor;.\driver\mpu6050;.\driver\ms5611;.\driver\NRF24L01;.\driver\table;.\driver\ultrasound
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/src/: main.c delay.c lolv.c sys.c
  group lib
    ./lib/src/: iap.c flash.c myiic.c lib_helper.c usart.c
  group driver
    ./driver/NRF24L01/: nrf.c
    ./driver/hmc5883/: hmc5883.c
    ./driver/motor/: motor.c
    ./driver/mpu6050/: mpu6050.c
    ./driver/ms5611/: ms5611.c
  group software
    ./software/src/: AC_PID.c AttitudeControl.c AP_Motor.c RC_Channel.c matrix3f.c vector3f.c ahrs_dcm.c cmath.c vector2f.c AP_InertialSensor.c radio.c AP_Curve.c stabilize.c Scheduler.c F3Copter.c paramter.c ano.c Compass.c sbus.c land_detector.c AP_State.c events.c notify.c Attitude.c InertialNav.c PosControl.c althold.c LowPassFilter.c barometer.c inertia.c AP_Buffer.c DerivativeFilter.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
